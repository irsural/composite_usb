# IAR project USBD_DualCore.ewp, settings and files
configuration STM32H743I-EVAL_USBD (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; USE_HAL_DRIVER; USE_IOEXPANDER; USE_USB_HS; IRS_USE_UTF8_CPP=1; IRS_STM32H7xx
  ICCARM.CCDiagSuppress: Pa039, Pe261, Pe340, Pa050, Pa091, Pa089, Go005, Pe193, Pa137, Pe826, Pe237, Pe2349, Pe1873, Pe068, Pa109
  ICCARM.CCIncludePath2: ..\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\Drivers\BSP\STM32H743I-EVAL; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\BSP\Components\Common; ..\..\Drivers\CMSIS/Device\ST\STM32H7xx\Include; ..\..\..\mxsrclib; ..\..\..\mxsrclib\arch\arm_st_hal; ..\..\..\extern_libs\utf8cpp\source\utf8; ..\..\..\extern_libs\utf8cpp\source\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: USBD_DualCore.bin
  ILINK.IlinkOutputFile: STM32H743I-EVAL_USBD_DualCore.out
  ILINK.IlinkIcfFile: stm32h7xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User/Inc
    ../Inc/: main.h stm32h743i_eval_conf.h stm32h7xx_hal_conf.h stm32h7xx_it.h usbd_cdc_desc.h usbd_cdc_interface.h usbd_conf.h usbd_desc.h usbd_hid_desc.h
  group Application/User/Src
    ../Src/: main.cpp stm32h7xx_hal_msp.c stm32h7xx_it.c usbd_cdc_desc.c usbd_cdc_interface.c usbd_conf.c usbd_hid_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_bus.c stm32h743i_eval_io.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/STM32_USBD_Library/Core
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group mxsrclib/Arch
    ../../../mxsrclib/: correct_alg.cpp correct_alg.h csvwork.cpp csvwork.h dbgprn.cpp dbgprn.h hardflowg.cpp hardflowg.h imp_filt.cpp imp_filt.h irs_chart_data.cpp irs_chart_data.h irs_codecvt.h irsadc.cpp irsadc.h irsadcabs.h irsalg.cpp irsalg.h irscalc.cpp irscalc.h irschartwin.h irsconfig.h irsconfig0.h irsconsole.h irsconsolestd.h irscpp.h irscpu.cpp irscpu.h irsdacabs.h irsdbgutil.cpp irsdbgutil.h irsdcp.cpp irsdcp.h irsdefs.h irsdefsbase.h irsdev.cpp irsdev.h irsdevices.cpp irsdevices.h irsdsp.cpp irsdsp.h irsencode.h irserror.cpp irserror.h irsexcept.cpp irsexcept.h irsfilter.cpp irsfilter.h irsfinal.h irsfunnel.cpp irsfunnel.h irsgpio.cpp irsgpio.h irshfftp.cpp irshfftp.h irsinit.cpp irsinit.h irsint.cpp irsint.h irskbd.cpp irskbd.h irslimits.h irslineinterp.h irslocale.cpp irslocale.h irslwip.cpp irslwip.h irslwipbuf.h irsmath.cpp irsmath.h irsmatrix.cpp irsmatrix.h irsmbus.cpp irsmbus.h irsmcutil.cpp irsmcutil.h irsmem.cpp irsmem.h irsmenu.cpp irsmenu.h irsnetdefs.h irsparamabs.h irspch.h irsprop.cpp irsprop.h irsrect.h irsspi.h irsstd.cpp irsstd.h irsstrconv.h irsstrconvbase.h irsstrdefs.h irsstring.cpp irsstring.h irsstrm.cpp irsstrm.h irsstrmstd.h irssysutils.cpp irssysutils.h irstable.h irstcpip.cpp irstcpip.h irstest.h irstime.cpp irstime.h irstree.h irsvariant.cpp irsvariant.h lwipopts_conf.h measdef.h measmul.cpp measmul.h meassup.cpp meassup.h mxdata.cpp mxdata.h mxdatastd.h mxextbase.cpp mxextbase.h mxextchart.cpp mxextchart.h mxifa.h mxifar.cpp mxifar.h mxnet.cpp mxnet.h mxnetc.cpp mxnetc.h mxnetd.h mxnetr.cpp mxnetr.h niusbgpib.cpp niusbgpib.h niusbgpib_hardflow.cpp niusbgpib_hardflow.h timer.cpp timer.h tstlan4abs.h
  group mxsrclib/Arch/Inc
    ../../../mxsrclib/arch/arm_st_hal/: counter.h mxifal.h mxnetda.h
  group mxsrclib/Arch/Src
    ../../../mxsrclib/arch/arm_st_hal/: counter.cpp
